Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:47+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-212-0418
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-212-0418 Тематический игровой комплекс «Железный конь»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Железный конь»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-212-0418; ModelReference: Тематический игровой комплекс «Железный конь»; ProductionYear: 2026; ArticleNumber: ZSK-212-0418
ORION_Изделие - Артикул: ZSK-212-0418; Артикул прежний: SD-212-0418; Наименование: Тематический игровой комплекс «Железный конь»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Возраст: для детей от 2 до 12 лет; Цена: 5 581 280 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/themed/3008; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс «Железный конь»; ADSK_Марка: ZSK-212-0418; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/themed/3008
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-212-0418
